# Keil uVision project co_op_scheduler.uvproj, settings and files
target Target 1 (MCS-51)
  device: ADuC847 Analog Devices
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0xF7FF) CLOCK(32768) DPX MODAB2
  output: co_op_scheduler
  c flags: Optimize=8 SizeSpeed=1
  link misc: NOOVERLAY
  group Source Group 1
    ./: START_AD.A51 main.c _sch51.obj _sch51_init.OBJ my_statemachine.c
